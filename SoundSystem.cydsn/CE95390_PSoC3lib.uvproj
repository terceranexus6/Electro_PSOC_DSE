# Keil uVision project CE95390_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CE95390_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h USBFS.c USBFS.h USBFS_audio.c USBFS_audio.h USBFS_boot.c USBFS_cdc.c USBFS_cdc.h USBFS_cls.c USBFS_descr.c USBFS_drv.c USBFS_episr.c USBFS_hid.c USBFS_hid.h USBFS_pm.c USBFS_std.c USBFS_vnd.c USBFS_cdc.inf USBFS_midi.c USBFS_midi.h USBFS_pvt.h VDAC8.c VDAC8.h VDAC8_PM.c Speaker.c Speaker.h Speaker_aliases.h VDACoutDMA_dma.c VDACoutDMA_dma.h VDACoutDMA_done_isr.c VDACoutDMA_done_isr.h Clock_1.c Clock_1.h LCD.c LCD.h LCD_PM.c USBFS_ep2_dma.c USBFS_ep2_dma.h USBFS_Dm.c USBFS_Dm.h USBFS_Dm_aliases.h USBFS_Dp.c USBFS_Dp.h USBFS_Dp_aliases.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CE95390_PSoC3lib (library)
  c flags: Optimize=5
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
